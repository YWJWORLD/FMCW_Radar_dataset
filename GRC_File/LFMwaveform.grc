options:
  parameters:
    category: '[Radar Waveform Blocks]'
    generate_options: hb
    id: LFMwaveform
    output_language: python
    title: LFM Waveform Block
  states: {}

blocks:
- name: amp
  id: parameter
  parameters:
    label: Amplitude
    type: eng_float
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp
    freq: samp_rate/1.3e3
    offset: offset
    phase: ''
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: vco_amplitude
    samp_rate: samp_rate
    sensitivity: samp_rate
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '50'
    win: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: offset
  id: parameter
  parameters:
    label: Offset
    type: eng_float
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampling Rate
    type: eng_float
    value: '0'
  states: {}
- name: vco_amplitude
  id: parameter
  parameters:
    label: Vco amplitude
    type: eng_float
    value: '0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_vco_f_0, '0']
- [blocks_vco_f_0, '0', hilbert_fc_0, '0']
- [hilbert_fc_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
