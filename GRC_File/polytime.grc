options:
  parameters:
    generate_options: qt_gui
    id: Polytime
    output_language: python
    title: polytime
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 910e6
  states: {}
- name: interp
  id: variable
  parameters:
    value: samp_rate/signal_freq
  states: {}
- name: n_segment
  id: variable
  parameters:
    value: '4'
  states: {}
- name: phase_state
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: signal_freq
  id: variable
  parameters:
    value: samp_rate/4
  states: {}
- name: source_amplitude
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: Polytimewaveform_1
  id: Polytimewaveform
  parameters:
    Kind_of_signal: T1
    center_freq: 910e6
    delta_f: '2000'
    interp: 2e6/500e3
    phase_state: '2'
    samp_rate: 2e6
    segment: '4'
    signal_freq: 2e6/4
    source_amplitude: '1'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/wjyun/Radar_generator/Examples/Radar_waveform_generation/T1/T1_test.bin
    type: complex
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: 2048*1000
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: int(1e6)
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_addr: addr=166.104.231.199
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: center_freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: addr=166.104.231.198
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [Polytimewaveform_1, '0', qtgui_time_sink_x_0, '0']
- [Polytimewaveform_1, '0', uhd_usrp_sink_0, '0']
- [blocks_head_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_skiphead_0, '0', blocks_head_0_0, '0']
- [dc_blocker_xx_0, '0', blocks_skiphead_0, '0']
- [uhd_usrp_source_1, '0', dc_blocker_xx_0, '0']
- [uhd_usrp_source_1, '0', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
