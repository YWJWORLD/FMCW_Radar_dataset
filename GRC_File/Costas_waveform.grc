options:
  parameters:
    category: '[Radar Waveform Blocks]'
    generate_options: hb
    id: Costas_waveform
    output_language: python
    title: Costas Waveform Blocks
  states: {}

blocks:
- name: multi_const
  id: variable
  parameters:
    value: prime_number-1
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(seq_len / (prime_number-1))
    type: float
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: source_amplitude
    samp_rate: samp_rate
    sensitivity: samp_rate
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, primitive_root = 2, prime_number = 11):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Costas Code Vector Source',   # will show up in GRC
                  in_sig=None,
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.root = primitive_root
              self.number = prime_number
              
          def work(self, input_items,output_items):
              """example: multiply with constant"""
              items = []
              multiply_const = int(100*(self.number-1))        
              for i in range(1, self.number):
                  items = np.r_[items, (self.root ** i) % self.number] 
              
              items = items * multiply_const
              for i in range(len(output_items[0])):
                  output_items[0][i] = items[i%(self.number-1)] 
              return len(output_items[0])
    prime_number: prime_number
    primitive_root: primitive_root
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: prime_number
  id: parameter
  parameters:
    label: Prime Number
    type: eng_float
    value: '11'
  states: {}
- name: primitive_root
  id: parameter
  parameters:
    label: Primitive Root
    type: eng_float
    value: '2'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampling Rate
    type: eng_float
    value: '0'
  states: {}
- name: seq_len
  id: parameter
  parameters:
    label: Length of Sequence
    type: eng_float
    value: '1024'
  states: {}
- name: source_amplitude
  id: parameter
  parameters:
    label: Source amplitude
    type: eng_float
    value: '1'
  states: {}

connections:
- [blocks_float_to_complex_0, '0', pad_sink_0, '0']
- [blocks_repeat_0, '0', blocks_vco_f_0, '0']
- [blocks_vco_f_0, '0', blocks_float_to_complex_0, '0']
- [blocks_vco_f_0, '0', blocks_float_to_complex_0, '1']
- [epy_block_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
