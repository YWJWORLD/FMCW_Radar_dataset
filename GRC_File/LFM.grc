options:
  parameters:
    generate_options: qt_gui
    id: LFM
    output_language: python
    title: LFM
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 910e6
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '50'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_num
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: source_amplitude
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: LFMwaveform_0
  id: LFMwaveform
  parameters:
    amp: '0.5'
    offset: '0'
    samp_rate: samp_rate
    vco_amplitude: source_amplitude
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/wjyun/Radar_generator/Examples/Radar_waveform_generation/record/LFM_wire_test.bin
    type: complex
  states: {}
- name: blocks_head_0_0_0
  id: blocks_head
  parameters:
    num_items: 2048*100
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: int(3e4)
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_addr: addr=166.104.231.199
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: center_freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: addr=166.104.231.198
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [LFMwaveform_0, '0', uhd_usrp_sink_0, '0']
- [blocks_head_0_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_skiphead_0, '0', blocks_head_0_0_0, '0']
- [dc_blocker_xx_0, '0', blocks_skiphead_0, '0']
- [uhd_usrp_source_1, '0', dc_blocker_xx_0, '0']
- [uhd_usrp_source_1, '0', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
